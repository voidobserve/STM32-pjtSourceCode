# Keil uVision project project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM;..\DEVICE_LIB\inc;..\CMSIS;..\HARDWARE\KEY;..\HARDWARE\LED;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\HARDWARE\BEEP;..\HARDWARE\RTC;..\HARDWARE\TIM;..\HARDWARE\USART3;..\HARDWARE\ULTRAVIOLET_LIGHT;..\HARDWARE\FAN;..\HARDWARE\DUST_SENSOR;..\HARDWARE\DHT11;..\HARDWARE\MS1100;..\HARDWARE\OLED;.\APP;..\HARDWARE\ESP8266;..\HARDWARE\USART2;..\FreeRTOS\INCLUDE;..\FreeRTOS\PORT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s
  group SYSTEM
    ../SYSTEM/: system_stm32f4xx.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group DEVICE_LIB
    ../DEVICE_LIB/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_adc.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/TIM/: tim.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/ULTRAVIOLET_LIGHT/: ultraviolet_light.c
    ../HARDWARE/FAN/: fan.c
    ../HARDWARE/DUST_SENSOR/: dust_sensor.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/MS1100/: ms1100.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/USART2/: usart2.c
  group FreeRTOS_SRC
    ../FreeRTOS/SOURCE/: list.c queue.c tasks.c
  group FreeRTOS_PORT
    ../FreeRTOS/PORT/: heap_4.c port.c
  group APP
    ./APP/: interface.c mqtt.c cJSON.c child_safety_lock.c
  group USER
    ./: stm32f4xx_it.c main.c my_config.h FreeRTOSConfig.h
